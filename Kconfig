## Kconfig
```kconfig
config SECURITY_BOBULSM
	bool "BOBULSM"
	depends on SECURITY
	select NETWORK_SECMARK
	default n
```
